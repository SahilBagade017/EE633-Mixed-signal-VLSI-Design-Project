*** testing 4 bit flash

************ defining Vdd and clk and inputs*************
VDD vdd gnd DC 1.8V
Vclk1 clk gnd PULSE (1.8 0 0 0.1n 0.1n 2.5n 5n)
Vclk2 clk_bar gnd PULSE (0 1.8 0 0.1n 0.1n 2.5n 5n)
Vin s_h_in gnd SIN(0 1.8 1MEG 0 0)
Vbias nmos_bias gnd 0.9

*********************************************************

************ include tsmc 180 model file **************
.include tsmc_spice_model.txt
********************************************************

*********************************************************
.include s_h_tran.cir
*********************************************************

************ include sense comaprator  **************
.include sense_comparator.cir
********************************************************

************ include inverter  **************
.include inverter.cir
********************************************************

************ include clocked comparator  **************
.include clocked_comparator.cir
********************************************************

************ include XOR to generate bubble code  **************
.include bubble_XOR.cir
********************************************************

*********************************************************
.include preamp.cir
*********************************************************

*********************************************************
.include pmos_preamp.cir
*********************************************************

*********************************************************
.include or_8ip.cir
*********************************************************

*********************************************************
.include adc_4.cir
*********************************************************

********************************* sample and hold *********************************
xs_h gnd clk_bar clk s_h_in adc_in s_h_tran
***********************************************************************************

************************* 3 bit flash *********************************************
xadc1 vdd gnd nmos_bias clk adc_in adc_out_bit0 adc_out_bit1 adc_out_bit2 adc_out_bit3 adc_4
***********************************************************************************

.END
